# Keil uVision project VHB15A.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: VHB15A +hex
  c flags: Optimize=9
  c include: ..\HARDWARE\ds1302;..\HARDWARE\ds18b20;..\HARDWARE\lcd;..\HARDWARE\RX8010;..\HARDWARE\sht21;..\HARDWARE\sht31;..\HARDWARE\w25x;..\SYSTEM\delay;..\SYSTEM\stc_eeprom;..\SYSTEM;..\CODE
  group 0Basic_Definition
    ../SYSTEM/: stc12c32ad.h data_type.h
    ../CODE/: all.h
    ../SYSTEM/stc_eeprom/: stc_eeprom.c stc_eeprom.h
    ../SYSTEM/delay/: delay.c delay.h
  group 1System_Timescale
    ../CODE/: Main_Tik_Tok.c Main_Tik_Tok.h
  group 2Task_Management
    ../CODE/: WS_Task_Manage.c WS_Task_Manage.h
  group 3Foreground_Task
    ../CODE/: Main_Tik_Function.c Main_Tik_Function.h Sub_Tik_Function.c Sub_Tik_Function.h
  group 4Normal_Task
    ../CODE/: Normal_Task.c Normal_Task.h
  group 5Activity_Functions
    ../CODE/: ActivityFunctions.c ActivityFunctions.h Sound_Type.c Sound_Type.h main.c StcRomCrc16.c StcRomCrc16.h
  group 6HardwareDriver
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/w25x/: w25x.c
    ../HARDWARE/sht21/: sht21.c
    ../HARDWARE/RX8010/: RX8010.c
    ../HARDWARE/DS18b20/: ds18b20.c
  group 7KeyFunctions
    ../CODE/: key_datas.c key_datas.h Key_Multifun.c Key_Multifun.h
  group 8GUI
    ../CODE/: GUI.c GUI.h
  group 9UART
    ../CODE/: uart_fun.c uart_fun.h
  group 10ChangeRecord
    ../: ChangeRecord.txt
